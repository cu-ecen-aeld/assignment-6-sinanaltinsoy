## conf/local.conf
```bitbake
MACHINE = "qemuarm64"
#check connectivity using google
CONNECTIVITY_CHECK_URIS = "https://www.google.com/"
```
